Commit message: add cleanup task

File: cliport/environments/assets/ur5/workspace.urdf (robot description, URDF)
Before this commit: robot workspace.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=2.0 3.0 0.01; visual mesh filename=plane.obj scale=0.0167 0.0333 1
